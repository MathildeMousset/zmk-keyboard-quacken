## Kconfig
```kconfig
config ZMK_BEHAVIOR_DEAD_KEY
  bool
  default y
  depends on DT_HAS_ZMK_BEHAVIOR_DEAD_KEY_ENABLED

# Enable mouse buttons
CONFIG_ZMK_POINTING=y
```
